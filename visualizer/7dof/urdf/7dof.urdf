Commit message: polished up everything

File: visualizer/7dof/urdf/7dof.urdf (robot description, URDF)
Before this commit: robot GEN3_7DOF_WITH_EPICK, 11 links, 10 joints
Joints:
- joint Actuator1: origin xyz=0 0 0.15643 rpy=3.1416 2.7629E-18 -4.9305E-36 -> xyz=0 0 0.15643 rpy=3.1416 2.7629E-18 0
